# Keil uVision project HSA.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: HSA +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: delay_1ms.c DS1621.c hsa.c serial_com.c lcd.c i2c.c
